# Keil uVision project IIC.uvproj, settings and files
target IIC (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: IIC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\IIC
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/IIC/: iic.c
