# Keil uVision project 温度传感器.uvproj, settings and files
target 温度传感器 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 温度传感器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\TEMP;..\HARDWARE\DIGITRON
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/TEMP/: temp.c
    ../HARDWARE/DIGITRON/: digitron.c
