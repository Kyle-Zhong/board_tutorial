# Keil uVision project 电机.uvproj, settings and files
target 电机 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 电机 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\MOTOR
  group USER
    ./: main.c
  group HARDWERA
    ../HARDWARE/MOTOR/: motor.c
