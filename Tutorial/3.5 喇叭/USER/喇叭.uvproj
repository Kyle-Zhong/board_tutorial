# Keil uVision project 喇叭.uvproj, settings and files
target 喇叭 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 喇叭 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\BORN
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/BORN/: born.c music.c
