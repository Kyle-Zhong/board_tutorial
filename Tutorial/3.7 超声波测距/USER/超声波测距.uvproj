# Keil uVision project 超声波测距.uvproj, settings and files
target ULTRASONIC (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 超声波测距 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\ULTRASONIC;..\HARDWARE\DIGITRON
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/DIGITRON/: digitron.c
    ../HARDWARE/ULTRASONIC/: ultrasonic.c
